## conf/machine/imx7dsabre-custom.conf
```bitbake
require conf/machine/imx7dsabresd.conf

KERNEL_DEVICETREE = "imx7dsabre-custom.dtb"
# UBOOT_MACHINE = "imx7dsabre-custom_defconfig"
```
